<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_radio</value></param>
<param><key>title</key><value>OFDM Modem</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>gr-mac</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>backoff_db</value></param>
<param><key>value</key><value>-15.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>label</key><value>msg_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Front: 128 is too short, Tail: 8 is adequate</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>msg_in</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>foo_burst_tagger</key>
<param><key>id</key><value>foo_burst_tagger_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>tag_name</key><value>pmt.intern("length")</value></param>
<param><key>mult</key><value>1</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>pad_front</key><value>16*4 * 4</value></param>
<param><key>pad_tail</key><value>16</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>packet_len_key</key><value>length</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0 + 4</value></param>
</block>
<block>
<key>mac_burst_tagger</key>
<param><key>id</key><value>mac_burst_tagger_0</value></param>
<param><key>tag_name</key><value>'length'</value></param>
<param><key>mult</key><value>1</value></param>
<param><key>pad_front</key><value>256</value></param>
<param><key>pad_rear</key><value>16</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_1</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>packet_len_key</key><value>"length"</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>10.0**(1.0*backoff_db/10.0)</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>digital_ofdm_rx_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>pdus</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_burst_tagger_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>mac_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_burst_tagger_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>digital_ofdm_rx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
